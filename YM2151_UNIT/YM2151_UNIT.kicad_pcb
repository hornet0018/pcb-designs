# Repository hornet0018/pcb-designs

File README.md:

# pcb-designs

このリポジトリは基板設計データをまとめるためのリポジトリです。

## KiCadを使用した基板設計リポジトリ

- [universal_power_board](https://github.com/hornet0018/universal_power_board)
- [CAT4238_Unit](https://github.com/hornet0018/CAT4238_Unit)
- [L298N-DRIVER](https://github.com/hornet0018/L298N-DRIVER)

## KiCad design YM2151_UNIT/YM2151_UNIT.kicad_pcb

Parts:
C1: CC0603KRX7R9BB104; C0603; LCSC C14663
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_DIN965_Pad
J1: Power; PinSocket_1x08_P2.54mm_Vertical
J2: Analog; PinSocket_1x06_P2.54mm_Vertical
J5: Digital/PWM; PinSocket_1x10_P2.54mm_Vertical
J6: Digital/PWM; PinSocket_1x08_P2.54mm_Vertical
LED2, LED3: 17-21SUYC/TR8; LED0805-R-RD; LCSC C2296
R1, R11: 0603WAF3001T5E; R0603; LCSC C4211
R2, R3, R4, R5, R6, R7, R8, R9: 0603WAF4701T5E; R0603; LCSC C23162
R10: 0603WAF1002T5E; R0603; LCSC C25804
U2, U4, U5, U6: 2N7002; SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR; LCSC C8545
U3: MCP23S17-E/SP; DIP-28_L34.6-W7.3-P2.54-LS10.2-BL; LCSC C148096
U7: S07B-PASK-2(LF)(SN); CONN-TH_S07B-PASK-2-LF-SN; LCSC C265397

Connections:
+3V3: R3.2, R4.2, R6.2, R8.2, U2.1 (G), U4.1 (G), U5.1 (G), U6.1 (G), U7.7
+5V: C1.2, J1.5, R1.2, R2.2, R5.2, R7.2, R9.2, R10.2, R11.2, U3.9 (VDD), U7.6
/3V3_CS: R3.1, U2.2 (S), U7.5
/3V3_SCK: R8.1, U6.2 (S), U7.2
/3V3_SI: R6.1, U5.2 (S), U7.3
/3V3_SO: R4.1, U4.2 (S), U7.4
/CS: R2.1, U2.3 (D), U3.11 (CS#)
/D0: J6.6, U3.21 (GPA0)
/D1: J6.5, U3.22 (GPA1)
/D2: J6.4, U3.23 (GPA2)
/D3: J6.3, U3.24 (GPA3)
/D4: J6.2, U3.25 (GPA4)
/D5: J6.1, U3.26 (GPA5)
/D6: J5.10, U3.27 (GPA6)
/D7: J5.9, U3.28 (GPA7)
/SCK: R9.1, U3.12 (SCK), U6.3 (D)
/SI: R7.1, U3.13 (SI), U5.3 (D)
/SO: R5.1, U3.14 (SO), U4.3 (D)
/YM_A0: J5.6, U3.4 (GPB3)
/YM_IC: J5.5, U3.5 (GPB4)
/YM_RD: J5.8, U3.2 (GPB1)
/YM_WR: J5.7, U3.3 (GPB2)
GND: C1.1, J1.6, J1.7, J5.4, LED2.2 (-), U3.10 (VSS), U3.15 (A0), U3.16 (A1), U3.17 (A2), U7.1
unnamed: LED2.1 (+), R1.1
unnamed: LED3.1 (+), R11.1
unnamed: LED3.2 (-), U3.1 (GPB0)
unnamed: R10.1, U3.18 (RESET#)

Notes on the sheet:
改訂履歴 rev2_2026_08_12 rev1_2026_08_06_新規

Board: 2 copper layers, 61.0 x 54.3 mm, 28 parts (0 on the bottom side), 27 nets.

File YM2151_UNIT/jlcpcb_output/assembly/YM2151_UNIT-bom-jlc.csv:

Comment,Designator,Footprint,LCSC Part #
CC0603KRX7R9BB104,C1,C0603,
Power,J1,PinSocket_1x08_P2.54mm_Vertical,
Analog,J2,PinSocket_1x06_P2.54mm_Vertical,
Digital/PWM,J5,PinSocket_1x10_P2.54mm_Vertical,
Digital/PWM,J6,PinSocket_1x08_P2.54mm_Vertical,
17-21SUYC/TR8,LED2,LED0805-R-RD,
17-21SUYC/TR8,LED3,LED0805-R-RD,
0603WAF3001T5E,R1,R0603,
0603WAF4701T5E,R2,R0603,
0603WAF4701T5E,R3,R0603,
0603WAF4701T5E,R4,R0603,
0603WAF4701T5E,R5,R0603,
0603WAF4701T5E,R6,R0603,
0603WAF4701T5E,R7,R0603,
0603WAF4701T5E,R8,R0603,
0603WAF4701T5E,R9,R0603,
0603WAF1002T5E,R10,R0603,
0603WAF3001T5E,R11,R0603,
2N7002,U2,SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR,
MCP23S17-E/SP,U3,DIP-28_L34.6-W7.3-P2.54-LS10.2-BL,
2N7002,U4,SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR,
2N7002,U5,SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR,
2N7002,U6,SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR,
S07B-PASK-2(LF)(SN),U7,CONN-TH_S07B-PASK-2-LF-SN,

## KiCad design m5_spi_module/m5_spi_module.kicad_pcb

Parts:
H5, H6, H7, H8: MountingHole; MountingHole_3.2mm_M3
H9, H10, H11, H12: MountingHole; MountingHole_2.2mm_M2
J1: Conn_02x15_Odd_Even; PinSocket_2x15_P2.54mm_Vertical
JP1, JP2, JP3, JP4: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R2, R3, R4, R5, R6, R7, R8, R9: 0603WAF4701T5E; R0603; LCSC C23162
U2, U4, U5, U6: 2N7002; SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR; LCSC C8545
U3: S02B-PASK-2(LF)(SN); CONN-TH_S02B-PASK-2-LF-SN; LCSC C265094
U7: S07B-PASK-2(LF)(SN); CONN-TH_S07B-PASK-2-LF-SN; LCSC C265397

Connections:
+3V3: J1.12, R3.2, R4.2, R6.2, R8.2, U2.1 (G), U4.1 (G), U5.1 (G), U6.1 (G), U7.7
+5V: J1.28, R2.2, R5.2, R7.2, R9.2, U3.2, U7.6
+BATT: J1.30
/CS: JP1.2 (B), R2.1, U2.3 (D), U7.5
/EN: J1.6
/GPIO0: J1.24
/GPIO1: J1.14
/GPIO2: J1.19
/GPIO3: J1.13
/GPIO5: J1.20
/GPIO12: J1.21
/GPIO13: J1.22
/GPIO15: J1.23
/GPIO16: J1.15, JP4.1 (A), R8.1, U6.2 (S)
/GPIO17: J1.16, JP1.1 (A), R3.1, U2.2 (S)
/GPIO18: J1.11
/GPIO19: J1.9
/GPIO21: J1.17
/GPIO22: J1.18
/GPIO23: J1.7
/GPIO25: J1.8
/GPIO26: J1.10, JP3.1 (A), R6.1, U5.2 (S)
/GPIO34: J1.26
/GPIO35: J1.2
/GPIO36: J1.4, JP2.1 (A), R4.1, U4.2 (S)
/SCK: JP4.2 (B), R9.1, U6.3 (D), U7.2
/SI: JP3.2 (B), R7.1, U5.3 (D), U7.3
/SO: JP2.2 (B), R5.1, U4.3 (D), U7.4
GND: J1.1, J1.3, J1.5, U3.1, U7.1
VBUS: J1.25, J1.27, J1.29

Board: 2 copper layers, 50.0 x 50.0 mm, 27 parts (0 on the bottom side), 12 nets.

File m5_spi_module/jlcpcb_output/assembly/m5_spi_module-bom-jlc.csv:

Comment,Designator,Footprint,LCSC Part #
Conn_02x15_Odd_Even,J1,PinSocket_2x15_P2.54mm_Vertical,
0603WAF4701T5E,R2,R0603,
0603WAF4701T5E,R3,R0603,
0603WAF4701T5E,R4,R0603,
0603WAF4701T5E,R5,R0603,
0603WAF4701T5E,R6,R0603,
0603WAF4701T5E,R7,R0603,
0603WAF4701T5E,R8,R0603,
0603WAF4701T5E,R9,R0603,
2N7002,U2,SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR,
S02B-PASK-2(LF)(SN),U3,CONN-TH_S02B-PASK-2-LF-SN,
2N7002,U4,SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR,
2N7002,U5,SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR,
2N7002,U6,SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR,
S07B-PASK-2(LF)(SN),U7,CONN-TH_S07B-PASK-2-LF-SN,
